Commit message: Adding gazebo related stuff

File: src/simulation/urdf/model.urdf (robot description, URDF)
Before this commit: robot my_robot, 5 links, 4 joints
Links:
- link central_piece: mass None -> .1
- link left_rod: mass None -> .1
- link right_rod: mass None -> .1
